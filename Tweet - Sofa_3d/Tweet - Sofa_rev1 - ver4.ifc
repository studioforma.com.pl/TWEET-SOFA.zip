Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tweet - Sofa_rev1 - ver4.ifc
Time: 2022-12-30T10:49:14
Author: utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
